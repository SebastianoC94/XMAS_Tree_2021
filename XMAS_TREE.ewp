# IAR project XMAS_TREE.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F2P STM8L101F2P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: BSP; $PROJ_DIR$; TEST; LIBS; LIBS\LED; LIBS\PWM; LIBS\TIMER; LIBS\RANDOM; LIBS\FRAME_BUFFER; LIBS\FRAME_BUFFER\GENERATOR; LIBS\FRAME_BUFFER\CONTROLLER; HAL\STM8L10x_StdPeriph_Driver; HAL\STM8L10x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group BSP
    BSP/: bsp_conf.h
  group HAL/STM8L10X
    HAL/STM8L10x_StdPeriph_Driver/: stm8l10x_conf.h stm8l10x_it.c stm8l10x_it.h
  group HAL/STM8L10X/INC
    HAL/STM8L10x_StdPeriph_Driver/inc/: stm8l10x.h stm8l10x_awu.h stm8l10x_beep.h stm8l10x_clk.h stm8l10x_comp.h stm8l10x_exti.h stm8l10x_flash.h stm8l10x_gpio.h stm8l10x_i2c.h stm8l10x_irtim.h stm8l10x_itc.h stm8l10x_iwdg.h stm8l10x_rst.h stm8l10x_spi.h stm8l10x_tim2.h stm8l10x_tim3.h stm8l10x_tim4.h stm8l10x_usart.h stm8l10x_wfe.h
  group HAL/STM8L10X/SRC
    HAL/STM8L10x_StdPeriph_Driver/src/: stm8l10x_awu.c stm8l10x_beep.c stm8l10x_clk.c stm8l10x_comp.c stm8l10x_exti.c stm8l10x_flash.c stm8l10x_gpio.c stm8l10x_i2c.c stm8l10x_irtim.c stm8l10x_itc.c stm8l10x_iwdg.c stm8l10x_rst.c stm8l10x_spi.c stm8l10x_tim2.c stm8l10x_tim3.c stm8l10x_tim4.c stm8l10x_usart.c stm8l10x_wfe.c
  group LIBS/LED/INC
    LIBS/LED/: led.h
  group LIBS/LED/SRC
    LIBS/LED/: led.c
  group LIBS/RANDOM
    LIBS/RANDOM/: random.c random.h
  group LIBS/TIMER
    LIBS/TIMER/: timer.c timer.h
  group TEST
    TEST/: test.c test.h
